# IAR project device_fw_template.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103x8 ST STM32F103x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: HSE_VALUE=16000000; USE_HAL_DRIVER; STM32F103xB
  ICCARM.CCIncludePath2: HAL\STM32F1xx_HAL_Driver\Inc; DEVICE\STM32F1xx\Include; DEVICE; $PROJ_DIR$; BSP\cs43l22; MWARE\STM32_USB_Device_Library\Core\Inc; MWARE\STM32_USB_Device_Library\Class\CustomHID\Inc; PERIPH
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: device_fw_template.bin
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: device_fw_template.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: README.md
  group 4. Middleware Level/USB_Device_Library/Class
    MWARE/STM32_USB_Device_Library/Class/CustomHID/Src/: usbd_customhid.c
  group 4. Middleware Level/USB_Device_Library/Core
    MWARE/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group 5. Board Level (BSP)
    BSP/ak4343/: ak4343.c
    BSP/cs43l22/: cs43l22.c
  group 6. Peripheral Level
    PERIPH/: i2c.c spi.c
    ./: main.c
  group 7. HAL Level
    HAL/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_can.c stm32f1xx_hal_cec.c stm32f1xx_hal_cortex.c stm32f1xx_hal_crc.c stm32f1xx_hal_dac.c stm32f1xx_hal_dac_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_eth.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_hcd.c stm32f1xx_hal_i2c.c stm32f1xx_hal_i2s.c stm32f1xx_hal_irda.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_msp.c stm32f1xx_hal_nand.c stm32f1xx_hal_nor.c stm32f1xx_hal_pccard.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_sd.c stm32f1xx_hal_smartcard.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_sram.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_wwdg.c stm32f1xx_ll_fsmc.c stm32f1xx_ll_sdmmc.c stm32f1xx_ll_usb.c
  group 8. Device Level
    DEVICE/STM32F1xx/Source/Templates/iar/: startup_stm32f103xb.s
    DEVICE/: stm32f1xx_it.c
    DEVICE/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group Tests
    ./: device_fw_template - Debug C-STAT summary.html
